# IAR project ZigbeeCoorMG1P.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG1P132F256GM48 SiliconLaboratories EFR32MG1P132F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: SERIAL_UART_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES1_CONFIG1_MICRO; PHY_RAIL; EFR32MG1P; EFR32MG1P132F256GM48; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeCoorMG1P/ZigbeeCoorMG1P_endpoint_config.h"; BOARD_HEADER="app/builder/ZigbeeCoorMG1P/ZigbeeCoorMG1P_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeCoorMG1P/ZigbeeCoorMG1P_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeCoorMG1P/ZigbeeCoorMG1P.h"; __SOURCEFILE__="$FILE_FNAME$"; BOARD_BRD4300B; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; EMLIB_USER_CONFIG; APPLICATION_TOKEN_HEADER="app/builder/ZigbeeCoorMG1P/afv2-token.h"; APPLICATION_MFG_TOKEN_HEADER="app/builder/ZigbeeCoorMG1P/afv2-mfg-token.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee_5.9\app\framework; ..\..\..\protocol\zigbee_5.9\app\framework\..\..; ..\..\..\protocol\zigbee_5.9\app\framework\..\..\stack; ..\..\..\protocol\zigbee_5.9\app\framework\..\util; ..\..\..\protocol\zigbee_5.9\app\framework\include; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\EFR32MG1P\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ecode; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\platform\base\hal\micro\cortexm3\efm32\board; ..\..\..\hardware\kit\common\bsp; ..\..\..\hardware\kit\EFR32MG1_BRD4300B\config; ..\..\..\platform\bootloader; Com; UART; Delay; AppEvent; ..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\radio\rail_lib\chip\efr32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: SERIAL_UART_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; PHY_RAIL; EFR32_SERIES1_CONFIG1_MICRO; EFR32MG1P; EFR32MG1P132F256GM48; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeCoorMG1P/ZigbeeCoorMG1P_endpoint_config.h"; BOARD_HEADER="app/builder/ZigbeeCoorMG1P/ZigbeeCoorMG1P_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeCoorMG1P/ZigbeeCoorMG1P_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeCoorMG1P/ZigbeeCoorMG1P.h"; BOARD_BRD4300B; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; EMLIB_USER_CONFIG; APPLICATION_TOKEN_HEADER="app/builder/ZigbeeCoorMG1P/afv2-token.h"; APPLICATION_MFG_TOKEN_HEADER="app/builder/ZigbeeCoorMG1P/afv2-mfg-token.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee_5.9\app\framework; ..\..\..\protocol\zigbee_5.9\app\framework\..\..; ..\..\..\protocol\zigbee_5.9\app\framework\..\..\stack; ..\..\..\protocol\zigbee_5.9\app\framework\..\util; ..\..\..\protocol\zigbee_5.9\app\framework\include; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\EFR32MG1P\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ecode; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\test; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\platform\base\hal\micro\cortexm3\efm32\board; ..\..\..\hardware\kit\common\bsp; ..\..\..\hardware\kit\EFR32MG1_BRD4300B\config; ..\..\..\platform\bootloader; Com; UART; Delay; AppEvent; ..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\radio\rail_lib\chip\efr32
  OBJCOPY.OOCOutputFile: ZigbeeCoorMG1P.s37
  postbuild: ZigbeeCoorMG1P.bat $TARGET_BPATH$ "$PROJ_DIR$"
  ILINK.IlinkOutputFile: ZigbeeCoorMG1P.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=262144; RAM_SIZE=32768; SERIAL_UART_BTL=1
  ILINK.IlinkIcfFile: ..\..\..\platform\base\hal\micro\cortexm3\efm32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../app/builder/ZigbeeCoorMG1P/: ZigbeeCoorMG1P_callbacks.c
    ../../../app/builder/ZigbeeCoorMG1P/AppEvent/: AppEvent.c
    ../../../app/builder/ZigbeeCoorMG1P/Com/: macro.c Template.c
    ../../../app/builder/ZigbeeCoorMG1P/Delay/: halDelay.c
    ../../../app/builder/ZigbeeCoorMG1P/UART/: Uart_CmdEnum.c Uart_CmdExec.c Uart_Receiver.c Uart_Transmitter.c
    ../../../platform/base/hal/micro/cortexm3/efm32/: bootloader-interface-standalone.c bootloader-interface.c assert-crash-handlers.c button.c cstartup-common.c diagnostic.c faults-v7m.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token.c ext-device.c
    ../../../platform/bootloader/api/: btl_interface.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/address-table/: address-table.c address-table-cli.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/concentrator/: concentrator-support.c concentrator-support-cli.c
    ../../../protocol/zigbee_5.9/app/util/: source-route-common.c source-route.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../../platform/base/hal/plugin/serial/: ember-printf.c serial.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/form-and-join/: form-and-join-afv2.c
    ../../../protocol/zigbee_5.9/app/util/common/: form-and-join.c form-and-join-node-adapter.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/identify/: identify.c identify-cli.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/identify-feedback/: identify-feedback.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/network-find/: network-find.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/ota-common/: ota-common.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/ota-server/: ota-server.c ota-server-page-request.c ota-server-cli.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/ota-server-policy/: ota-server-policy.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/ota-storage-common/: ota-storage-common.c ota-storage-common-cli.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/ota-storage-simple/: ota-storage-simple.c ota-storage-simple-simulation.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/ota-storage-simple-ram/: ota-storage-ram.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/scan-dispatch/: scan-dispatch.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/simple-main/: simple-main.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/simple-metering-client/: simple-metering-client.c simple-metering-client-cli.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/sleepy-message-queue/: sleepy-message-queue.c sleepy-message-queue-cli.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/time-server/: time-server.c
    ../../../platform/base/hal/plugin/debug/rtt/: SEGGER_RTT.c
    ../../../platform/base/hal/plugin/coexistence/: coexistence-efr32.c
    ../../../platform/base/hal/plugin/sim-eeprom1/: sim-eeprom.c
    ../../../platform/base/hal/plugin/antenna-stub/: antenna-stub.c
    ./: afv2-bookkeeping.c call-command-handler.c callback-stub.c stack-handler-stub.c cli.c
    ../../../protocol/zigbee_5.9/app/framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c print.c print-formatter.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c message.c multi-network.c time-util.c util.c
    ../../../protocol/zigbee_5.9/app/framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../../platform/base/hal/plugin/buzzer/: buzzer-efr32.c
    ../../../protocol/zigbee_5.9/app/framework/../util/serial/: command-interpreter2.c
    ../../../platform/base/hal/micro/generic/: crc.c endian.c mem-util.c random.c token-def.c
    ../../../protocol/zigbee_5.9/app/framework/../../stack/config/: ember-configuration.c
    ../../../protocol/zigbee_5.9/app/framework/../util/common/: library.c
    ../../../protocol/zigbee_5.9/app/framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../../protocol/zigbee_5.9/app/framework/../util/security/: security-address-cache.c
    ../../../platform/base/hal/plugin/serial/cortexm/efm32/: com.c
    ../../../platform/base/hal/: ember-base-configuration.c
    ../../../protocol/zigbee_5.9/app/framework/../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group emdrv
    ../../../platform/base/hal/../../emdrv/dmadrv/src/: dmadrv.c
    ../../../platform/base/hal/../../emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../platform/base/hal/../../emdrv/rtcdrv/src/: rtcdriver.c
    ../../../platform/base/hal/../../emdrv/sleep/src/: sleep.c
    ../../../platform/base/hal/../../emdrv/spidrv/src/: spidrv.c
    ../../../platform/base/hal/../../emdrv/tempdrv/src/: tempdrv.c
    ../../../platform/base/hal/../../emdrv/uartdrv/src/: uartdrv.c
    ../../../platform/base/hal/../../emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../platform/base/hal/../../emlib/src/: em_adc.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ldma.c em_leuart.c em_mpu.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../../platform/base/hal/../../Device/SiliconLabs/EFR32MG1P/Source/: system_efr32mg1p.c
  group Libraries
    ../../../protocol/zigbee_5.9/build/binding-table-library-cortexm3-iar-efr32mg1p-rail/: binding-table-library.a
    ../../../protocol/zigbee_5.9/build/cbke-163k1-stub-library-cortexm3-iar-efr32mg1p-rail/: cbke-163k1-stub-library.a
    ../../../protocol/zigbee_5.9/build/cbke-283k1-stub-library-cortexm3-iar-efr32mg1p-rail/: cbke-283k1-stub-library.a
    ../../../protocol/zigbee_5.9/build/cbke-stub-library-cortexm3-iar-efr32mg1p-rail/: cbke-stub-library.a
    ../../../protocol/zigbee_5.9/build/cbke-library-dsa-sign-stub-cortexm3-iar-efr32mg1p-rail/: cbke-library-dsa-sign-stub.a
    ../../../protocol/zigbee_5.9/build/cbke-library-dsa-verify-stub-cortexm3-iar-efr32mg1p-rail/: cbke-library-dsa-verify-stub.a
    ../../../protocol/zigbee_5.9/build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-efr32mg1p-rail/: cbke-library-dsa-verify-283k1-stub.a
    ../../../protocol/zigbee_5.9/build/debug-basic-library-cortexm3-iar-efr32mg1p-rail/: debug-basic-library.a
    ../../../protocol/zigbee_5.9/build/debug-extended-stub-library-cortexm3-iar-efr32mg1p-rail/: debug-extended-stub-library.a
    ../../../protocol/zigbee_5.9/build/end-device-bind-stub-library-cortexm3-iar-efr32mg1p-rail/: end-device-bind-stub-library.a
    ../../../protocol/zigbee_5.9/build/enhanced-beacon-request-stub-library-cortexm3-iar-efr32mg1p-rail/: enhanced-beacon-request-stub-library.a
    ../../../protocol/zigbee_5.9/build/gp-stub-library-cortexm3-iar-efr32mg1p-rail/: gp-stub-library.a
    ../../../protocol/zigbee_5.9/build/install-code-library-stub-cortexm3-iar-efr32mg1p-rail/: install-code-library-stub.a
    ../../../protocol/zigbee_5.9/build/multi-network-stub-library-cortexm3-iar-efr32mg1p-rail/: multi-network-stub-library.a
    ../../../protocol/zigbee_5.9/build/packet-validate-library-cortexm3-iar-efr32mg1p-rail/: packet-validate-library.a
    ../../../protocol/zigbee_5.9/build/rf4ce-stack-stub-library-cortexm3-iar-efr32mg1p-rail/: rf4ce-stack-stub-library.a
    ../../../protocol/zigbee_5.9/build/security-library-core-cortexm3-iar-efr32mg1p-rail/: security-library-core.a
    ../../../protocol/zigbee_5.9/build/security-library-link-keys-stub-cortexm3-iar-efr32mg1p-rail/: security-library-link-keys-stub.a
    ../../../protocol/zigbee_5.9/build/zigbee-pro-stack-cortexm3-iar-efr32mg1p-rail/: zigbee-pro-stack.a
    ../../../protocol/zigbee_5.9/build/zll-stub-library-cortexm3-iar-efr32mg1p-rail/: zll-stub-library.a
    ../../../protocol/zigbee_5.9/build/hal-library-cortexm3-iar-efr32mg1p-rail/: hal-library.a
    ../../../protocol/zigbee_5.9/build/sim-eeprom1-library-cortexm3-iar-efr32mg1p-rail/: sim-eeprom1-library.a
    ../../../platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg1_iar_release.a
